Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-10-10T12:12:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 10 12:12:18 2024 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\8f93c90a-c7b8-4513-8acb-ad717d5238bc\d3289253-7f49-4289-a512-4d96c557b89a\ifc * Database version: 5507 * Database creation date: Thu Oct 10 12:12:18 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 10 12:12:18 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 10 12:12:18 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 57932171 Cover part for washbasin faucet, 57932171(2020):57932171 Cover part for washbasin faucet:494390
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Type: 0
Type - Dimensions - NominalDepth: 234 mm; NominalHeight: 107.6 mm; NominalWidth: 175 mm
Type - General - Author: BIMStone; BIMObjectName: 57932171; ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - Approval ABP: PA-IX 38408/IO; Approval DVGW: DW-6512CS0518; EAN Number: 4015474178953; EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; Noise Class: I (ISO3822); Sales Package dimensions (LxWxH): 255 x 195 x 93; UNSPSC Class Number: 30181810 Faucet trim; URL ABP: http://static.hansa.com/ABP/57932171; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/57932171; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL DVGW: http://static.hansa.com/DVGW/57932171; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL REACH: http://static.hansa.com/doc/reach; URL UWL: http://static.hansa.com/UWL/57932171
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/57932171; 3D View: https://static.hansa.com/3D/57932171; Ambience photo: http://static.hansa.com/ambience/57932171; Catalog Drawing URL: http://static.hansa.com/catdrw/57932171; Category B2B: Public & Semi-public;Industry;Housing; Color variants: 5793217133; Dimension Drawing URL: http://static.hansa.com/dimdrw/57932171; FDV Document URL: http://www.hansa.com/datasheet/57932171/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/57932171; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/57932171; Interactive AR View URL: https://static.hansa.com/AR/57932171; Manufacturer: HANSA; Market: Austria;Belgium;Czech Republic;Germany;Spain;France;International;Italy;Netherlands;Slovakia; Mobile Product Information URL: http://mpi.hansa.com/57932171; Model: 57932171 Cover part for washbasin faucet; Name_en: 57932171 Cover part for washbasin faucet; OmniClass Number: 23.45.55.00; Product Code: 57932171; Product Family: HANSAPUBLIC; Product Image URL: http://static.hansa.com/image/57932171; Product URL: http://static.hansa.com/57932171; Spare-Part Information URL: http://static.hansa.com/sp/57932171; Technical DataSheet URL: http://www.hansa.com/datasheet/57932171/en; Type Name: 57932171 Cover part for washbasin faucet; Usage Group: Offices;Airports;SportsStadiums;Hotels;IndustrialBuildings;Households;Apartments;NewBuilding; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Advanced Features: Flexible length / can be shortened;Waterways without nickel coating; Aerator: Hidden aerator; Backflow Prevention EN1717: AA; Concealed Parts: Round rosette; Flow Rate At 300kPa With Flow Controller: 0.00459091 m3/s; Installation Type: Concealed wall mounting; Lever Handle: Single operating lever/handle;Hot/Cold symbols;Pin shape; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 2 hole; Spout Projection: 160-225 mm; Spout Type: Fixed spout;Profile construction; Surface treatment: Chrome; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 57932171(2020); Features: Single-lever;Trim Kit; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 57932171; Name: 57932171 Cover part for washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 175 x 235 x108 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 57932171 Cover part for washbasin faucet; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 57932171; Manufacturer: HANSA
Pset_ProductRequirements - Name: 57932171 Cover part for washbasin faucet; Category: Plumbing Fixtures
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0849654 m2; Volume: 0.00440687 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 57932171(2020): 57932171 Cover part for washbasin faucet; Family and Type: 57932171(2020): 57932171 Cover part for washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 57932171(2020): 57932171 Cover part for washbasin faucet; Type Id: 57932171(2020): 57932171 Cover part for washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
